# Keil uVision project f407.uvprojx, settings and files
target STM32F407VG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f407
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\mcu\stm\stm32f4xx\include;..\..\board\bottom\include;..\..\target\bottom\include;..\..\compiler\armcc;..\..\lib\os\include;..\..\lib\os\include\arch\cortex_m4;..\..\lib\c\include;..\..\lib\cmsis\include;.\include;..\..\lib\standard\include;..\..\lib\CanOpenNode\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group mcu\stm32f4xx
    ../../mcu/stm/stm32f4xx/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c
  group board\bottom
    ../../board/bottom/src/: board.c fgetc.c fputc.c system_stm32f4xx.c uart4.c startup_stm32f40xx.s systick.c i2c1.c at24c16.c
  group target\bottom
    ../../target/bottom/src/: tick.c
  group lib\os\cortex_m4
    ../../lib/os/src/arch/cortex_m4/: cpuport.c context_rvds.S
  group lib\os
    ../../lib/os/src/: os.c os_error.c os_event.c os_heap.c os_idle.c os_ipc.c os_irq.c os_list.c os_mbox.c os_misc.c os_mpool.c os_mqueue.c os_mutex.c os_sched.c os_sem.c os_task.c os_tick.c os_timer.c os_timer_task.c os_version.c
  group lib\CanOpenNode
    ../../lib/CanOpenNode/src/: CANopen.c CO_Emergency.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c CO_trace.c crc16-ccitt.c
  group lib\CanOpenNode\rt-thread
    ../../lib/CanOpenNode/src/rt-thread/: CO_os.c
  group lib\CanOpenNode\STM32F4
    ../../lib/CanOpenNode/src/STM32F4/: bxCAN.c CO_driver.c CO_eeprom.c
  group apps\bottom
    ./src/: application.c main.c main_loop.c CO_OD.c CO_loop.c
